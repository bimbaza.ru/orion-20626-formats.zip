Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:11+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-VB-M-12
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-VB-M-12 Вазон «Денеб» · мрамор «шахматка»
In: Площадка
Description: Изделие бетонное благоустройства. Вазон «Денеб» · мрамор «шахматка»; Classification: 05.3.02.03 Вазон уличный (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-VB-M-12; ModelReference: Вазон «Денеб» · мрамор «шахматка»; ProductionYear: 2026; ArticleNumber: ZSK-VB-M-12
ORION_Изделие - Артикул: ZSK-VB-M-12; Артикул прежний: SD-VB-M-12; Наименование: Вазон «Денеб» · мрамор «шахматка»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 1200×400×400 мм; Материал: Бетон; Цена: 80 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20626; Код КСИ: CPr>EDG010; Класс КСИ: Вазон уличный; Коды КСР: 05.3.02.03 … 59.1.15.02-0449
ADSK - ADSK_Наименование: Вазон «Денеб» · мрамор «шахматка»; ADSK_Марка: ZSK-VB-M-12; ADSK_Код изделия: 05.3.02.03; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20626
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDG010; ZSK_Артикул_прежний: SD-VB-M-12
Qto_ORION - Длина: 1200 mm; Ширина: 400 mm; Высота: 400 mm
